# Repository williamyang98/oculink_m2_adapter

File README.md:

# Introduction

Open source M.2 to Oculink adapter for the Lenovo Ideapad Pro 5 16ARP8 laptop. Includes a single board design and a flexible two board design.

Documentation on design, manufacturing and benchmarks can be found [here](https://williamyang98.github.io/oculink_m2_adapter/docs/)

## Single board design

## Flexible two board design

# Project guide
| Directory | Description |
| --- | --- |
| ```docs``` | Location of hugo docs which are published to [github pages](https://williamyang98.github.io/oculink_m2_adapter/docs/) |
| ```kicad``` | Location of KiCAD schematic and PCBs files |
| ```simuations``` | Location of openEMS Python simulations for parametric optimisation of transmission line hatched ground plane and tapers |

## KiCad design simulations/differential_hatched/differential.kicad_pcb

File simulations/differential_hatched/README.md:

# Introduction
- Simulates variants of hatched ground plane for flexible PCB design.
- Refer to ```kicad/oculink_m2_flex_connector/flex_pcb``` for the final design.

# Instructions
1. Create hatched ground plane simulation variants.
```bash
python ./generate_hatches.py
```

2. Simulate hatched ground plane variants.
```bash
python ../run_simulations.py
```

3. Search for optimum hatch plane configuration.
```bash
python ../find_optimum_diffpair.py
```

# Layout
| Filepath | Description |
| --- | --- |
| ```variants_simulation/base``` | Original simulation files |
| ```variants_simulation/variants.csv``` | Stores list of variants |
| ```variants_simulation/variants/*/images/*_debug.png``` | Stores debug images of hatch ground plane variant |
| ```variants_optimum_diffpair``` | Stores S-parameter and Smith chart plots of hatch ground plane variants |

Parts:
GND1: Ground; pad_0.1mm
SP0, SP1, SP2, SP3: Simulation_Port; pad_0.15mm

Connections:
/A_+: SP0.1, SP1.1
/A_-: SP2.1, SP3.1
GND: GND1.1

Board: 2 copper layers, 1.5 x 3.2 mm, 5 parts (1 on the bottom side), 2 nets.

## KiCad design kicad/oculink_m2_flex_connector/oculink_port/oculink_port.kicad_pcb

File kicad/oculink_m2_flex_connector/README.md:

# Introduction
Contains KiCAD 8.0 schematics and PCB designs for flexible multi-PCB M.2 to Oculink adapter.

| Directory | Description |
| --- | --- |
| ```flex_pcb``` | Flexible PCB which connects M.2 card to Oculink port board |
| ```m2_card``` | M.2 2242 card |
| ```oculink_port``` | Oculink port board which is installed in left speaker position in 16ARP8 Lenovo Ideapad Pro 5 |

Parts:
C1, C5: 100n; C_0402_1005Metric; LCSC Part C513772
J1: G14A42121B12HR; AMPHENOL_G14A42121B12HR; PARTREV D; LCSC Part C5156927
J2: Conn_01x38_Pin; port_pcb
JP1: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
TP2: TP_GND_2; TestPoint_Pad_D1.0mm

Connections:
3.3V: C1.1, J1.B21 (3.3V), JP1.1 (A)
3.3V_OPT: C5.1, J2.33, JP1.2 (B)
CLKREQ: J1.B13 (CPRSNT), J2.29
CLOCK+: J1.A12 (CLOCK+), J2.2
CLOCK-: J1.A13 (CLOCK-), J2.3
GND: C1.2, C5.2, J1.A2 (GND), J1.A5 (GND), J1.A8 (GND), J1.A11 (GND), J1.A14 (GND), J1.A17 (GND), J1.A20 (GND), J1.B2 (GND), J1.B5 (GND), J1.B8 (GND), J1.B11 (GND), J1.B14 (GND), J1.B17 (GND), J1.B20 (GND), J1.SH1 (SHIELD_1), J1.SH2 (SHIELD_2), J1.SH3 (SHIELD_3), J1.SH4 (SHIELD_4), J2.1, J2.4, J2.7, J2.10, J2.13, J2.16, J2.19, J2.22, J2.25, J2.28, J2.34, TP2.1
PEDET: J1.A9 (RESERVED), J2.32
PERST: J1.B12 (PERST), J2.30
PEWAKE: J1.A10 (CWAKE), J2.31
RX0+: J1.A3 (PERp0), J2.8
RX0-: J1.A4 (PERn0), J2.9
RX1+: J1.A6 (PERp1), J2.14
RX1-: J1.A7 (PERn1), J2.15
RX2+: J1.A15 (PERp2), J2.20
RX2-: J1.A16 (PERn2), J2.21
RX3+: J1.A18 (PERp3), J2.26
RX3-: J1.A19 (PERn3), J2.27
SMB+: J1.B10 (DATA)
SMB-: J1.B9 (CLOCK)
TX0+: J1.B3 (PETp0), J2.5
TX0-: J1.B4 (PETn0), J2.6
TX1+: J1.B6 (PETp1), J2.11
TX1-: J1.B7 (PETn1), J2.12
TX2+: J1.B15 (PETp2), J2.17
TX2-: J1.B16 (PETn2), J2.18
TX3+: J1.B18 (PETp3), J2.23
TX3-: J1.B19 (PETn3), J2.24

Notes on the sheet:
Digikey Link

Board: 4 copper layers, 20.7 x 87.1 mm, 6 parts (6 on the bottom side), 25 nets.

## KiCad design kicad/oculink_m2_flex_connector/m2_card/m2_card.kicad_pcb

File kicad/README.md:

# Introduction
Contains KiCAD 8.0 schematics and PCB designs for M.2 to Oculink adapter.

| Directory | Description |
| --- | --- |
| ```custom_components``` | Includes Amphenol Oculink port KiCAD files and custom flexible PCB connector |
| ```oculink_m2_single``` | Single board M.2 to Oculink card |
| ```oculink_m2_flex_connector``` | Flexible multi-board M.2 to Oculink card |

Parts:
C1, C2: 100n; C_0402_1005Metric; LCSC Part C513772
D1: D_Schottky; D_SOD-523; LCSC Part C475624
E1: m2_m_key
H1: M2_MOUNT; m2_ground_hole
J1: Conn_01x38_Pin; port_pcb
JP1: JMP_PEDET; 3pin_4state_jumper
JP2: JMP_PEWAKE; 3pin_4state_jumper
TP1: TP_GND_1; TestPoint_Pad_D1.0mm

Connections:
+3.3V: C1.1, E1.2 (3.3V), J1.33
+3.3V0: C2.2, E1.70 (3.3V), E1.72 (3.3V), E1.74 (3.3V)
/CLKREQ_EXT: D1.1 (K), J1.29
CLKREQ: D1.2 (A), E1.52 (~CLKREQ)
CLOCK+: E1.55 (REFCLKp), J1.2
CLOCK-: E1.53 (REFCLKn), J1.3
GND: C1.2, C2.1, E1.1 (GND), E1.3 (GND), E1.9 (GND), E1.15 (GND), E1.21 (GND), E1.27 (GND), E1.33 (GND), E1.39 (GND), E1.45 (GND), E1.51 (GND), E1.57 (GND), E1.71 (GND), E1.73 (GND), E1.75 (GND), H1.1, J1.1, J1.4, J1.7, J1.10, J1.13, J1.16, J1.19, J1.22, J1.25, J1.28, J1.34, JP1.2 (C), JP2.2 (C), TP1.1
unnamed: J1.31, JP2.3 (B)
unnamed: J1.32, JP1.3 (B)
PEDET: E1.69 (PEDET), JP1.1 (A)
PERST: E1.50 (~PERST), J1.30
PEWAKE: E1.54 (~PEWAKE), JP2.1 (A)
RX0+: E1.43 (PERp0), J1.8
RX0-: E1.41 (PERn0), J1.9
RX1+: E1.31 (PERp1), J1.14
RX1-: E1.29 (PERn1), J1.15
RX2+: E1.19 (PERp2), J1.20
RX2-: E1.17 (PERn2), J1.21
RX3+: E1.7 (PERp3), J1.26
RX3-: E1.5 (PERn3), J1.27
SMB+: E1.42 (SMB_DATA)
SMB-: E1.40 (SMB_CLOCK)
TX0+: E1.49 (PETp0), J1.5
TX0-: E1.47 (PETn0), J1.6
TX1+: E1.37 (PETp1), J1.11
TX1-: E1.35 (PETn1), J1.12
TX2+: E1.25 (PETp2), J1.17
TX2-: E1.23 (PETn2), J1.18
TX3+: E1.13 (PETp3), J1.23
TX3-: E1.11 (PETn3), J1.24

Board: 4 copper layers, 42.0 x 22.0 mm, 9 parts (1 on the bottom side), 28 nets.

## KiCad design kicad/oculink_m2_single/oculink_m2.kicad_pcb

Parts:
C1, C2, C3, C4, C5: 100n; C_0402_1005Metric; LCSC Part C513772
D1: Power LED; LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder; LCSC Part C434442
D2: D_Schottky; D_SOD-523; LCSC Part C475624
E1: m2_m_key
H1: M2_MOUNT; m2_ground_hole
H2: MOUNT_1; secondary_mounting_hole
H3: MOUNT_2; secondary_mounting_hole
J1: G14A42121B12HR; AMPHENOL_G14A42121B12HR; PARTREV D; LCSC Part C5156927
JP1: JMP_PEDET; 3pin_4state_jumper
JP2: JMP_3.3V_EXT; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP3: JMP_PEWAKE; 3pin_4state_jumper
R1: 100; R_0603_1608Metric; LCSC Part C22775
TP1: TP_GND_1; TestPoint_Pad_D1.0mm
TP9: TP_GND_2; TestPoint_Pad_D1.0mm

Connections:
3.3V_OPT: C3.1, J1.B21 (3.3V), JP2.2 (B), R1.1
+3.3V: C1.1, C2.1, C4.1, C5.1, E1.2 (3.3V), E1.4 (3.3V), E1.12 (3.3V), E1.14 (3.3V), E1.16 (3.3V), E1.18 (3.3V), E1.70 (3.3V), E1.72 (3.3V), E1.74 (3.3V), JP2.1 (A)
/CLKREQ_EXT: D2.1 (K), J1.B13 (CPRSNT)
/PEDET_EXT: J1.A9 (RESERVED), JP1.3 (B)
/PEWAKE_EXT: J1.A10 (CWAKE), JP3.3 (B)
CLKREQ: D2.2 (A), E1.52 (~CLKREQ)
CLOCK+: E1.55 (REFCLKp), J1.A12 (CLOCK+)
CLOCK-: E1.53 (REFCLKn), J1.A13 (CLOCK-)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, D1.1 (K), E1.1 (GND), E1.3 (GND), E1.9 (GND), E1.15 (GND), E1.21 (GND), E1.27 (GND), E1.33 (GND), E1.39 (GND), E1.45 (GND), E1.51 (GND), E1.57 (GND), E1.71 (GND), E1.73 (GND), E1.75 (GND), H1.1, J1.A2 (GND), J1.A5 (GND), J1.A8 (GND), J1.A11 (GND), J1.A14 (GND), J1.A17 (GND), J1.A20 (GND), J1.B2 (GND), J1.B5 (GND), J1.B8 (GND), J1.B11 (GND), J1.B14 (GND), J1.B17 (GND), J1.B20 (GND), J1.SH1 (SHIELD_1), J1.SH2 (SHIELD_2), J1.SH3 (SHIELD_3), J1.SH4 (SHIELD_4), JP1.2 (C), JP3.2 (C), TP1.1, TP9.1
unnamed: D1.2 (A), R1.2
PEDET: E1.69 (PEDET), JP1.1 (A)
PERST: E1.50 (~PERST), J1.B12 (PERST)
PEWAKE: E1.54 (~PEWAKE), JP3.1 (A)
RX0+: E1.43 (PERp0), J1.A3 (PERp0)
RX0-: E1.41 (PERn0), J1.A4 (PERn0)
RX1+: E1.31 (PERp1), J1.A6 (PERp1)
RX1-: E1.29 (PERn1), J1.A7 (PERn1)
RX2+: E1.19 (PERp2), J1.A15 (PERp2)
RX2-: E1.17 (PERn2), J1.A16 (PERn2)
RX3+: E1.7 (PERp3), J1.A18 (PERp3)
RX3-: E1.5 (PERn3), J1.A19 (PERn3)
SMB+: E1.42 (SMB_DATA), J1.B10 (DATA)
SMB-: E1.40 (SMB_CLOCK), J1.B9 (CLOCK)
TX0+: E1.49 (PETp0), J1.B3 (PETp0)
TX0-: E1.47 (PETn0), J1.B4 (PETn0)
TX1+: E1.37 (PETp1), J1.B6 (PETp1)
TX1-: E1.35 (PETn1), J1.B7 (PETn1)
TX2+: E1.25 (PETp2), J1.B15 (PETp2)
TX2-: E1.23 (PETn2), J1.B16 (PETn2)
TX3+: E1.13 (PETp3), J1.B18 (PETp3)
TX3-: E1.11 (PETn3), J1.B19 (PETn3)

Notes on the sheet:
Digikey Link

Board: 4 copper layers, 104.7 x 113.2 mm, 18 parts (9 on the bottom side), 31 nets.

## Commit log

2024-09-22 Updated footprints
2024-09-22 Fixed dimensions of m2 connector
2024-09-22 Removed mounting hole from footprint
2024-09-22 Added mounting hole as separate component
2024-09-23 Updated edge connector pinout
2024-09-23 Added adtlink adapter diagram
2024-09-23 Update m2 connector pinout from adtlink schematic
2024-09-24 Temporary mockup of adtlink adapter
2024-09-24 Preliminary routing of pcie lanes over bottleneck in pcb
2024-09-24 Finished prototype of potentially ready adapter
2024-09-24 Added instructions for generating jlcpcb files
2024-09-24 Updated with jlcpcb plot settings
2024-09-24 Fixed soldermask layer revealing a pcie trace
2024-09-24 Improved ground stitching and fix skew on clock differential pair
2024-09-25 Swapped SMB pair to connect clock/data correctly
2024-09-25 Updated impedance calculations with sierra circuits values and jlcpcb datasheet
2024-09-25 Added working copy of gpdwin vertical adapter to confirm correct pinout
2024-09-26 Added additional mounting holes for adapter
2024-09-26 Fixed position of additional mounting holes and made them oval vertically for potential vertical adjustment of adapter
2024-09-26 Fixed ground pour overflowing onto m2 edge connector
2024-09-28 Added stackup information to schematic
2024-09-28 Added soldermask web between pads to prevent solder bridging during smd assembly
2024-09-28 Fixed mounting holes
2024-09-28 Added bill of material and smd parts positioning scripts
2024-09-28 Updated bom script and added in schottky diode on clkreq
2024-09-28 Production pcb ordered to jlcpcb
2024-09-28 Cleanup traces
2024-09-29 Added design rule check for 85ohm impedance matched differential pairs
2024-09-29 Fixed up diff pair custom rules
2024-09-29 Updated design rules to allow for denser via fence
2024-09-29 Start of dense via layout
2024-09-29 Applied vias to half of board
2024-09-29 Finished right angle section
2024-09-30 Finished applying vias to connector section
2024-10-16 Added benchmark results
2024-10-20 Moved custom components to separate folder
2024-11-18 Added flex pcb design
2024-11-28 Initial layout of port side board
2024-11-28 Set correct impedance on port pcb
2024-11-28 Finished first draft of m2 card
2024-11-28 Crude flex pcb layout
2024-11-28 Test design for consistent hatched ground plane
2024-11-29 Unified taper geometry across pcbs
2024-11-29 Added taper for ground ffc pads
2024-12-01 Added mounting for port
2024-12-01 Shifted location of ffc connector to avoid screw mount
2024-12-01 Initial design and layout for flex pcb
2024-12-01 Finished initial layout of hatched plane for differential traces
2024-12-01 Finished via fencing on flex pcb
2024-12-01 Added design rule checks to m2 card pcb
2024-12-01 Generate plots for manufacturing
2025-01-10 Added flex pcb benchmarks
2025-01-15 Added dot points for documentation
2025-01-21 Setup hugo docs
2025-01-21 Filled out documentation with dot points
2025-01-22 Added toc to each doc section
2025-01-22 Updated docs
2025-01-24 Updated transmission line design docs
2025-01-27 Fixed MathJax missing fonts
2025-01-27 Updated design section of docs for transmission lines
2025-01-29 Added github action to publish hugo documentation
2025-01-29 gh-pages creation
2025-01-29 deploy: 8db805479af8f31227f5252d64886872bd1f2e31
2025-01-29 Fix table of contents for /docs
2025-01-29 deploy: 44cd56d58c64d0d8c3f097abf2e72dd0a356b521
2025-01-29 deploy: 3cfb13a98e10fe2cbace78c44d43b14c9b901d08
2025-01-29 Static assets reference baseurl correctly
2025-01-29 deploy: 0bd505e14c3ad837986cf960452d469f321411ec
2025-02-02 Added gerber2ems in simulation folder
2025-02-02 Added hatched ground plane simulation setup
2025-02-04 Graph and find optimum variant for diff pair matching
2025-02-04 Generate debug image for hatched ground plane
2025-02-04 Added differential taper parametric search
2025-02-04 Added README for simulation setup
2025-02-04 Updated parametric search for taper
2025-02-06 Updated taper simulation
2025-02-06 Updated trace width to 0.15mm instead of 0.1mm
2025-02-06 Added openEMS section
2025-02-06 Added manufacturing details
2025-02-06 deploy: fc6fb3ceb6ab4a109f51644f8735019375f7ead1
2025-02-07 Added image zoom
2025-02-07 deploy: eb00ce924af0841667bd21e19a4cd1179c17f524
2025-02-07 Finished first draft of docs
2025-02-07 deploy: 769a5a91a2e63f6f06943699a593ceb2205b9636
2025-02-07 deploy: 31b5f740f5bd52bd5e9b8ca4baa58e93c73ba8af
2025-02-07 deploy: 61bbac3cd28885dc5841e2a8733f09aaa7ad818d
2025-02-07 deploy: 9333e17d75a13845bce5287c7667d20daf50b4bf
2025-02-07 deploy: 207e12795962ed7d354b7a6acf4875ce09341117
2025-02-07 Use base url correctly
2025-02-07 deploy: 0b7ccf691ce0fcfba5ab5f884dd5d4a3bfb103a4
2025-02-07 deploy: 0113b7d338569facba4d0c9e757a51f35eb8290c
2025-02-07 Specify absolute path correctly
2025-02-07 deploy: 81039bc298ffe7cabe1d636755001bec3bf9055c
2026-01-01 deploy: 1bed49e7aac18907689a8cb8d4a5663f2b37f5d5
2026-01-01 Added Nvidia 5060Ti benchmarks
2026-01-01 deploy: f05f09ac6ffeaebaa42a03c31a12fd47bb8d5d2f
