File: kicad/oculink_m2_flex_connector/flex_pcb/flex_pcb.kicad_pcb (KiCad board)
At the start: 2 copper layers, 82.9 x 76.9 mm, 2 parts, among them J1 Conn_01x38_Pin, J2 Conn_01x38_Pin

Commit message: Finished via fencing on flex pcb
Routing:
- net GND: vias 692 -> 2143
